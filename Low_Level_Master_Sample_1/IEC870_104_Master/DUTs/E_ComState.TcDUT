TYPE E_ComState :
(
	INIT := 0,
	IDLE,
	CONNECT,
	DATATRANSFER,
	STOPDATATRANSFER,
	CLOSESOCKET
);
END_TYPE
